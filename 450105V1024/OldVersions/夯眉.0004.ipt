# Autodesk Inventor part: 본체
## iProperties
Created: 2015-01
Part Number: 본체
Document SubType Name: Modeling
Designer: kb54305
Density: 1 g/cm^3
Author: kb54305
